# Remove ksmro from mesa PACKEAGECONFIG
PACKAGECONFIG:remove:rpi = "kmsro"
