PACKAGECONFIG:append = " wayland-only "
